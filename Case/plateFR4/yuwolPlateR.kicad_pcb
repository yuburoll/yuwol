File: Case/plateFR4/yuwolPlateR.kicad_pcb (KiCad board)
At the start: 2 copper layers, 173.5 x 126 mm, 0 parts

Commit message: add catch phrase
Other:
- board text added: "yes, you are all good."
